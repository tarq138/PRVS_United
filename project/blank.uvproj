# Keil uVision project blank.uvproj, settings and files
target MDR32F9Qx (ARM-ADS)
  device: MDR32F9Q1I Milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: blank +hex
  c flags: Optim=1
  c include: ..\CMSIS;..\project;..\source;..\SPL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group StartUp
    ./: startup_MDR32F9x.s
  group MSIS
    ../CMSIS/: system_MDR32F9Qx.c
  group SPL
    ../SPL/: MDR32F9Qx_adc.c MDR32F9Qx_arinc429r.c MDR32F9Qx_arinc429t.c MDR32F9Qx_audio.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_keypad.c MDR32F9Qx_led.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
  group source
    ../source/: main.c
